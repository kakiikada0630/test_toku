# Repository kakiikada0630/test_toku

## EAGLE design 回路/untitled.brd

Parts:
1-1, 1-1(+B)1, 1-2, 1-2(GND)1, 1-3, 1-3(5V)1, 1-4(BOOST)1, 1-9, 1-21, 1-22, 1-23, 1-24, 1-25, 1-26, 1-27, 1-28, 1-29, 1-30, 1-31, 1-32, 2-1, 2-5, 2-6, 2-9, 2-10, 2-17, 2-18, 2-19, 2-20, 2-21, 2-22, 2-23, 2-24, 2-25, 2-26, 2-27, 2-28, 2-29, 2-30, 2-31, 2-32, 2-33, 2-34, 2-35, 2-36, 3-1, 3-6, 3-9, 3-10, 3-11, 3-12, 3-13, 3-14, 3-15, 3-16, 3-17, 3-18, 3-19, 3-20, 3-21, 3-22, 3-23, 3-24, 3-25, 3-26, 3-27, 3-28, 3-29, 3-30, 3-31, 3-32, 5VA, 5VB, 11-2, 11-4: PINHD-1X1; 1X01
A1, A2: PINHD-1X1; 1X01
AD_A1, AD_A2: PINHD-1X1; 1X01
AD_B1, AD_B2, AD_B3: PINHD-1X1; 1X01
B1, B2, B3: PINHD-1X1; 1X01
BST_E: PINHD-1X1; 1X01
BST_S: PINHD-1X1; 1X01
BUCK1_1, BUCK1_2, BUCK2_1: LEDCHIP-LED0603; CHIP-LED0603
BUCK_2_2: LEDCHIP-LED0603; CHIP-LED0603
CLK: PINHD-1X1; 1X01
CS_BK1, CS_BK2: PINHD-1X1; 1X01
CS_BST: PINHD-1X1; 1X01
D1, D2, D3: DIODE-SOD523; SOD523
DEBG1: PINHD-1X1; 1X01
H/L: TL39PO; TL3XPO
HL_BK: PINHD-1X1; 1X01
IG1: TL39PO; TL3XPO
JP1: PINHD-2X10; 2X10
JP2: PINHD-2X9; 2X09
JP3: PINHD-2X8; 2X08
JP4, JP5, JP6, JP7, JP8, JP9, JP13, JP17, JP18, JP19, JP20, JP21, JP22, JP23, JP24, JP25, JP26, JP27, JP28, JP29, JP30, JP31, JP32, JP33, JP34, JP35, JP36, JP37, JP38, JP39, JP40, JP41, JP42, JP43, JP44, JP45, JP46, JP47, JP48, JP49, JP50, JP51, JP52, JP53, JP54, JP55, JP56, JP57, JP58, JP60: PINHD-1X3; 1X03
JP10, JP11, JP12, JP14, JP15, JP16: PINHD-1X15; 1X15
JP59, JP61: PINHD-1X16; 1X16
JP63: PINHD-1X4; 1X04
LED_5VA, LED_5VB: LEDCHIP-LED0603; CHIP-LED0603
LED_BOOST: LEDCHIP-LED0603; CHIP-LED0603
LED_IG1: LEDCHIP-LED0603; CHIP-LED0603
LED温1, LED温2, LED温3: PINHD-1X1; 1X01
MISO: PINHD-1X1; 1X01
MOSI: PINHD-1X1; 1X01
Q1, Q2, Q5: 2SJ626; SOT23
Q3, Q4, Q6, Q7: BSS138; SOT23
R1, R2, R3, R4, R5, R6: 1k; R0603
R7, R8, R9, R10, R13, R14, R15, R16, R17, R18, R19: 4.7k; R0603
R11, R12: 100; R0603
TURN: TL39PO; TL3XPO
TURN_S: PINHD-1X1; 1X01
U$1: MCP4728
UDIM1-1, UDIM1-2, UDIM2-1: PINHD-1X1; 1X01
UDM2-2: PINHD-1X1; 1X01
U_RX: PINHD-1X1; 1X01
U_TX: PINHD-1X1; 1X01
VBST: PINHD-1X1; 1X01
VBU: TL39PO; TL3XPO
内温: PINHD-1X1; 1X01
放電: PINHD-1X1; 1X01
電源: PINHD-1X2; 1X02

Connections:
5VA: 1-4(BOOST)1.1, 5VA.1, JP1.3, JP61.1, JP61.2, JP61.3, JP61.4, JP61.5, JP61.6, JP61.7, JP61.8, JP61.9, JP61.10, JP61.11, JP61.12, JP61.13, JP61.14, JP61.15, JP61.16, Q5.2 (S), R1.2, R11.2, R17.2, TURN.1 (O)
5VB: 1-3(5V)1.1, 5VB.1, JP1.4, R2.2
+B: 1-1(+B)1.1, 1-2.1, JP1.2
+B(電源): IG1.3 (S), Q1.2 (S), Q2.2 (S), R13.2, R14.2, VBU.3 (S), 電源.2
A1: 3-28.1, A1.1, JP3.8, JP10.4
A2: 3-20.1, A2.1, JP3.7, JP10.5
AD_A1: 2-31.1, AD_A1.1, JP2.8
AD_A2: 2-22.1, AD_A2.1, JP2.7
AD_B1: 2-29.1, AD_B1.1, JP2.4
AD_B2: 2-20.1, AD_B2.1, JP2.3
AD_B3: 2-28.1, AD_B3.1, JP2.2
B1: 3-26.1, B1.1, JP3.4, JP16.12
B2: 3-18.1, B2.1, JP3.3, JP16.13
B3: 3-25.1, B3.1, JP3.2, JP16.14
BCK1UDIM1: 1-26.1, JP1.8, R4.2, UDIM1-1.1
BCK1UDIM2: 11-2.1, JP1.7, R3.2, UDIM1-2.1
BCK2UDIM1: 1-25.1, JP1.6, JP10.15, R5.2, UDIM2-1.1
BCK2UDIM2: 1-1.1, JP1.5, JP10.14, R6.2, UDM2-2.1
BSTENABLE: 1-28.1, BST_E.1, JP1.12
BSTSYNC: 11-4.1, BST_S.1, JP1.11
DEBUG1: 1-27.1, DEBG1.1, JP1.10
DISCHARGE: 3-19.1, JP3.5, JP16.11, 放電.1
ESP32_HL_BKUP: JP16.6, Q6.1 (G), R18.1
ESP32_SPI_CS: D1.A, D2.A, D3.A, JP10.3, R11.1
ESP32_TURN_SYNC: JP16.4, Q7.1 (G), R19.2
ESP_IG1_SW: JP10.10, Q3.1 (G), R15.2
ESP_VBU_SW: JP10.11, Q4.1 (G), R16.2
GND: BUCK1_1.C, BUCK1_2.C, BUCK2_1.C, BUCK_2_2.C, H/L.1 (O), JP10.2, JP11.2, JP12.2, JP14.2, JP15.2, JP16.2, JP59.1, JP59.2, JP59.3, JP59.4, JP59.5, JP59.6, JP59.7, JP59.8, JP59.9, JP59.10, JP59.11, JP59.12, JP59.13, JP59.14, JP59.15, JP59.16, JP63.1, LED_5VA.C, LED_5VB.C, LED_BOOST.C, LED_IG1.C, Q3.2 (S), Q4.2 (S), Q6.2 (S), Q7.2 (S), R15.1, R16.1, R18.2, R19.1, U$1.P$10 (VSS), 電源.1
HL_BKUP: 2-24.1, H/L.2, HL_BK.1, JP2.11, Q6.3 (D)
IG1: IG1.2, JP63.2, Q1.3 (D), R12.2
INSIDE_THM: 2-35.1, JP2.16, U$1.P$6 (O_A), 内温.1
LED_THM1: 2-26.1, JP2.15, LED温1.1, U$1.P$7 (O_B)
LED_THM2: 2-34.1, JP2.14, LED温2.1, U$1.P$8 (O_C)
LED_THM3: 2-25.1, JP2.13, LED温3.1, U$1.P$9 (O_D)
LIN_TX: 2-18.1, 2-36.1, JP2.18, JP10.7
unnamed: LED_5VB.A, R2.1
unnamed: LED_5VA.A, R1.1
unnamed: BUCK1_1.A, R4.1
unnamed: R7.2, R9.1
unnamed: R8.2, R10.1
unnamed: JP4.1, JP4.2, JP4.3
unnamed: JP5.1, JP5.2, JP5.3
unnamed: JP6.1, JP6.2, JP6.3
unnamed: JP7.1, JP7.2, JP7.3
unnamed: JP8.1, JP8.2, JP8.3
unnamed: JP9.1, JP9.2, JP9.3
unnamed: JP13.1, JP13.2, JP13.3
unnamed: JP17.1, JP17.2, JP17.3
unnamed: JP18.1, JP18.2, JP18.3
unnamed: JP19.1, JP19.2, JP19.3
unnamed: 1-3.1, 1-9.1, JP1.9
unnamed: JP20.1, JP20.2, JP20.3
unnamed: JP21.1, JP21.2, JP21.3
unnamed: BUCK1_2.A, R3.1
unnamed: 2-1.1, 2-19.1, JP2.1
unnamed: JP22.1, JP22.2, JP22.3
unnamed: 2-5.1, 2-21.1, JP2.5
unnamed: JP23.1, JP23.2, JP23.3
unnamed: 2-9.1, 2-23.1, JP2.9
unnamed: JP24.1, JP24.2, JP24.3
unnamed: JP25.1, JP25.2, JP25.3
unnamed: JP26.1, JP26.2, JP26.3
unnamed: 2-17.1, 2-27.1, JP2.17
unnamed: JP27.1, JP27.2, JP27.3
unnamed: JP28.1, JP28.2, JP28.3
unnamed: JP29.1, JP29.2, JP29.3
unnamed: 2-10.1, 2-32.1, JP2.10
unnamed: JP30.1, JP30.2, JP30.3
unnamed: 2-6.1, 2-30.1, JP2.6
unnamed: JP31.1, JP31.2, JP31.3
unnamed: JP32.1, JP32.2, JP32.3
unnamed: 3-1.1, 3-17.1, JP3.1
unnamed: JP33.1, JP33.2, JP33.3
unnamed: JP34.1, JP34.2, JP34.3
unnamed: JP35.1, JP35.2, JP35.3
unnamed: 3-9.1, 3-21.1, JP3.9
unnamed: 3-11.1, 3-22.1, JP3.11
unnamed: 3-13.1, 3-23.1, JP3.13
unnamed: 3-15.1, 3-24.1, JP3.15
unnamed: JP36.1, JP36.2, JP36.3
unnamed: JP14.3, JP15.3
unnamed: 3-6.1, 3-27.1, JP3.6
unnamed: JP37.1, JP37.2, JP37.3
unnamed: 3-10.1, 3-29.1, JP3.10
unnamed: 3-12.1, 3-30.1, JP3.12
unnamed: 3-14.1, 3-31.1, JP3.14
unnamed: 3-16.1, 3-32.1, JP3.16
unnamed: BUCK2_1.A, R5.1
unnamed: BUCK_2_2.A, R6.1
unnamed: JP38.1, JP38.2, JP38.3
unnamed: LED_BOOST.A, R7.1, R8.1
unnamed: Q5.1 (G), Q7.3 (D), R17.1
unnamed: LED_IG1.A, R12.1
unnamed: JP14.4, JP15.4
unnamed: Q1.1 (G), Q3.3 (D), R13.1
unnamed: Q2.1 (G), Q4.3 (D), R14.1
unnamed: JP14.5, JP15.5
unnamed: JP14.6, JP15.6
unnamed: JP14.7, JP15.7
unnamed: JP14.8, JP15.8
unnamed: JP14.9, JP15.9
unnamed: JP14.10, JP15.10
unnamed: JP14.11, JP15.11
unnamed: JP14.12, JP15.12
unnamed: JP14.13, JP15.13
unnamed: JP14.14, JP15.14
unnamed: JP14.15, JP15.15
unnamed: JP11.1, JP12.1
unnamed: JP39.1, JP39.2, JP39.3
unnamed: JP11.3, JP12.3
unnamed: JP11.4, JP12.4
unnamed: JP11.5, JP12.5
unnamed: JP11.6, JP12.6
unnamed: JP11.8, JP12.8
unnamed: JP11.7, JP12.7
unnamed: JP11.9, JP12.9
unnamed: JP11.10, JP12.10
unnamed: JP11.11, JP12.11
unnamed: JP11.12, JP12.12
unnamed: JP11.13, JP12.13
unnamed: JP11.14, JP12.14
unnamed: JP11.15, JP12.15
unnamed: JP10.8, U$1.P$2 (SCL)
unnamed: JP10.9, U$1.P$3 (SDA)
unnamed: JP40.1, JP40.2, JP40.3
unnamed: JP41.1, JP41.2, JP41.3
unnamed: JP42.1, JP42.2, JP42.3
unnamed: JP43.1, JP43.2, JP43.3
unnamed: JP44.1, JP44.2, JP44.3
unnamed: JP45.1, JP45.2, JP45.3
unnamed: JP46.1, JP46.2, JP46.3
unnamed: JP47.1, JP47.2, JP47.3
unnamed: JP48.1, JP48.2, JP48.3
unnamed: JP49.1, JP49.2, JP49.3
unnamed: JP50.1, JP50.2, JP50.3
unnamed: JP51.1, JP51.2, JP51.3
unnamed: JP52.1, JP52.2, JP52.3
unnamed: JP53.1, JP53.2, JP53.3
unnamed: JP54.1, JP54.2, JP54.3
unnamed: JP55.1, JP55.2, JP55.3
unnamed: JP56.1, JP56.2, JP56.3
unnamed: JP57.1, JP57.2, JP57.3
unnamed: JP58.1, JP58.2, JP58.3
unnamed: JP60.1, JP60.2, JP60.3
SPI_CLK: 1-32.1, CLK.1, JP1.20, JP16.5
SPI_CS_BK1: 1-30.1, CS_BK1.1, D1.C, JP1.16
SPI_CS_BK2: 1-22.1, CS_BK2.1, D2.C, JP1.15
SPI_CS_BST: 1-29.1, CS_BST.1, D3.C, JP1.14
SPI_MISO: 1-24.1, JP1.19, MISO.1
SPI_MOSI: 1-31.1, JP1.18, JP16.3, MOSI.1
TURN_SYNC: 2-33.1, JP2.12, Q5.3 (D), TURN.2, TURN_S.1
UARTRX: 1-21.1, JP1.13, U_RX.1
UARTTX: 1-23.1, JP1.17, JP10.6, U_TX.1
USB_5V: JP14.1, JP15.1, U$1.P$1 (VDD)
VBST: 1-2(GND)1.1, JP1.1, R9.2, R10.2, VBST.1
VBU: JP63.3, Q2.3 (D), VBU.2

Notes on the sheet:
5Va
IG1
VBoost
5Vb
USB_5V
Bck1 UDIM1
Bck1 UDIM2
Bck2 UDIM2
Bck2 UDIM1
H/L_Bkup
Turn_Sync
内気温
LED気温_1
LED気温_2
LED気温_3
SPI_CS
UART_Tx
VBU
Discharge
H/L Bkup SW
Turn Sync SW
SPI_MOSI
SPI_SCK
UDIM22
UDIM21

Board: 2 copper layers, 93.7 x 92.8 mm, 213 parts (23 on the bottom side), 156 nets.

## Commit log

2019-10-27 first commit!
2019-11-05 ○修正内容 1. UDIMのPWM受け口追加 2. バイナリ出力コマンド追加
2019-11-05 ○変更内容 1. PC用シリアル通信受信＋解析ソフトの追加
2019-11-06 ○修正内容 1. メイン引数で、COMポート名を与えるよう修正 2. dll化のためのバッチファイルを追加 3. dll化のための外部公開IFの作成 ⇒残 a) データ取得部はセマフォで同期する必要あり。 (でーたのファイル出力と同期) b) シリアルをオープンすると同時にスレッドを立てて、メインループをまわす。 c) シリアルのクローズIFを追加
2019-11-10 ○修正内容 1. 温度値取得対応
2019-11-10 ○修正内容
    １．温度値取得対応
    ２．PythonGUI対応
2019-11-11 ○修正内容 1. 軽微なバグの修正 2． メモリ領域の増設 3. esp32上アプリのmapファイル追加
2019-11-11 ○修正内容 1. 10以上のCOMポート番号への対応
2019-11-12 ○変更内容 1. ハング防止のため、printf関連処理を１スレッドのみとした ※esp32-idfでは、printf関連処理がスレッドセーフではないため
    2. メインスレッドのスタックサイズを10倍とした。
    ※アクセス異常によるハング対策(原因の特定はできていないが、現象が収まるか確認する)。
2019-11-23 ○修正内容 １． コマンド受信及び、stdoutを１つのスレッドで実施するよう変更 ※ タスクスイッチ時及び、stdin/outが同時に実施された際に ハングするように見えたため、同一スレッドですべて完結するよう 方式を修正する。
    ２． PC上アプリのビルド用パッチファイルの統合
    ３． Pythonアプリのボタン追加
    ※ vbu, ig1, turn, H/L bkup の各ボタンを作成
2019-11-26 ○修正内容 １． PC上アプリの、内部パラメータ初期化処理を追加 ※SPI/UARTが途切れた際に、内部保持するパラメータが 更新されない不具合が発生した。そのため、１ループするたび パラメータを初期化するよう変更した。
    ２． 「DebugApl.h」をC#から呼び出せるよう、ヘッダ定義を修正
2019-11-28 ○修正内容 １． PC上アプリの、内部パラメータ初期化処理を修正
2019-11-28 参考資料
2019-11-30 ○変更内容 1. 外部公開IFを呼び出した際のログファイル出力を追加 2. シリアルポートがオープンしていない場合のエラー処理を追加
2019-11-30 ○変更内容 1. クローズ時のエラー処理もれの修正 2. 処理のリトライ時間を4ms⇒1msに訂正 3. c#のサンプルプログラムの修正
2020-01-26 ・回路図追加 ・ＵＳＤＭ追加
2020-01-26 ポート表追加
2020-05-17 MMC_IO追加
2020-08-19 H23.5MYデモボード向けプログラム
2020-09-05 仕様追加 ・LINの読み出し追加 ・Orgログ出力フォーマットの変更
2020-10-18 3F0A向け追加
2020-11-27 名前付きパイプを設け、サーバ/クライアント用のＤＬＬファイルを生成した
    ○背景
    -元々、Ｔツールと灯火ツールで同じDllを使ってシリアル信号出力していた。
    -シリアル信号送信用ＣＯＭポートはどちらか１つからしかオープンできないため、
    ツールの共存ができなかった。
    ※灯火ツールから制御しつつ、Ｔツールでログをとることができなかった。
    -そこで、Ｔツールをサーバとし、ＣＯＭポートの送受信を一括管理することとし、
2020-11-30 DebugApl.dllの不具合修正 ⇒コマンドの送信サイズ誤り
2020-11-30 aaaaaa
2020-12-02 UARTデータ領域サイズ拡張 - UART領域データが一部ＬＩＮ領域にはみ出す件の暫定対策
2020-12-05 URATのＴｘタイムアウト時間が長い件の改善 ・各ボタン押下状況の取得を可能とした
2020-12-05 温度設定用のスライダーを追加
2021-08-07 +B用安定化電源制御コマンド対応
2021-08-07 データ更新
2021-08-07 バージョン更新 ・送信データが1回文ずれる件の修正 ・バージョンが正常に出ない件改善 ・+B用安定化電源への制御コマンド"vcc"対応
2021-08-07 新規回路図を追加
2021-08-07 HM310T仕様のためのシリアルドライバ追加
2021-08-07 以下の追加対応 ・+B安定化電源の制御ボタン追加 ・+B安定化電源制御用シリアルポートの初期化不備改善 ※初回はなぜかteratermで通信しないと通信できなかった件の改善
2021-08-25 uartによるコマンドが1バイトずれる問題の修正 ⇒>どうも、GPIOの入力割り込みが悪影響を与えているらしいことが分かった。 そのため、GPIOの割り込みを未使用の別コアで実行するよう変更した。
2021-08-25 VerID変更
2021-08-25 送信コマンドを送信直前にstdinN出力
2022-02-27 lin_can送信用治具
2022-05-05 デバッグシステムの概略資料
2022-12-26 デバッグボード
2023-01-08 新規デバッグボード向け環境
2025-03-16 説明書追加
